# Keil uVision project automeasure.uvproj, settings and files
target GPIO_OutputInput (5060020::V5.06 (build 20)::ARMCC)
  device: M0516LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: automeasure +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\Library\Device\Nuvoton\M051Series\Include;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\Library\Device;..\..\Library\StdDriver;..\..\Library\Nu-LB-M051
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../../Library/StdDriver/src/: retarget.c gpio.c uart.c clk.c sys.c timer.c
    D:/nuvoton_sample_code/Library/StdDriver/src/: adc.c
    D:/muilt-functional meassure/muilt-functional_meassurement_V2/Work/Library/StdDriver/src/: fmc.c
